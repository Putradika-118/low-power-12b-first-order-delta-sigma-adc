v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 1270 -717.5 1420 -717.5 {lab=Vop}
N 1420 -720 1420 -717.5 {lab=Vop}
N 1270 -693.75 1420 -693.75 {lab=Vom}
N 1420 -700 1420 -693.75 {lab=Vom}
N 1590 -700 1760 -700 {lab=Vout}
N 1760 -890 1760 -700 {lab=Vout}
N 1680 -890 1760 -890 {lab=Vout}
N 1760 -700 1760 -510 {lab=Vout}
N 1680 -510 1760 -510 {lab=Vout}
N 1760 -700 1780 -700 {lab=Vout}
N 1340 -740 1340 -717.5 {lab=Vop}
N 1420 -890 1440 -890 {lab=DAC-}
N 1420 -510 1440 -510 {lab=DAC+}
N 1340 -693.75 1340 -680 {lab=Vom}
N -660 -680 -660 -640 {lab=clk2B}
N -660 -580 -660 -560 {lab=0}
N -880 -1210 -880 -1170 {lab=VDD}
N -880 -1110 -880 -1090 {lab=0}
N -660 -1210 -660 -1170 {lab=VSS}
N -660 -1110 -660 -1090 {lab=0}
N -440 -1210 -440 -1170 {lab=Vbiasn}
N -440 -1110 -440 -1090 {lab=0}
N -180 -1210 -180 -1170 {lab=Vbiasp}
N -180 -1110 -180 -1090 {lab=0}
N -880 -930 -880 -890 {lab=Vin+}
N -880 -830 -880 -810 {lab=0}
N -660 -930 -660 -890 {lab=Vin-}
N -660 -830 -660 -810 {lab=0}
N -440 -930 -440 -890 {lab=clk1}
N -440 -830 -440 -810 {lab=0}
N -180 -930 -180 -890 {lab=clk2}
N -180 -830 -180 -810 {lab=0}
N -880 -680 -880 -640 {lab=VCM}
N -880 -580 -880 -560 {lab=0}
N -440 -680 -440 -640 {lab=Vref-}
N -440 -580 -440 -560 {lab=0}
N -180 -680 -180 -640 {lab=Vref+}
N -180 -580 -180 -560 {lab=0}
N 460 -1030 460 -890 {lab=#net1}
N 420 -890 460 -890 {lab=#net1}
N 460 -890 540 -890 {lab=#net1}
N 600 -890 640 -890 {lab=#net2}
N 640 -1030 640 -890 {lab=#net2}
N 640 -890 680 -890 {lab=#net2}
N 740 -890 780 -890 {lab=Vm}
N 340 -890 360 -890 {lab=Vin+}
N 310 -890 340 -890 {lab=Vin+}
N 710 -950 710 -930 {lab=clk2}
N 710 -950 740 -950 {lab=clk2}
N 680 -1060 740 -1060 {lab=clk1}
N 640 -1120 640 -1090 {lab=VSS}
N 460 -1120 460 -1090 {lab=DAC-}
N 460 -510 460 -370 {lab=#net3}
N 420 -510 460 -510 {lab=#net3}
N 460 -510 540 -510 {lab=#net3}
N 600 -510 640 -510 {lab=#net4}
N 640 -510 640 -370 {lab=#net4}
N 640 -510 680 -510 {lab=#net4}
N 740 -510 780 -510 {lab=Vp}
N 340 -510 360 -510 {lab=Vin-}
N 310 -510 340 -510 {lab=Vin-}
N 390 -470 390 -450 {lab=clk1}
N 360 -450 390 -450 {lab=clk1}
N 360 -340 420 -340 {lab=clk2}
N 710 -470 710 -450 {lab=clk2}
N 710 -450 740 -450 {lab=clk2}
N 680 -340 740 -340 {lab=clk1}
N 640 -310 640 -280 {lab=VSS}
N 460 -310 460 -280 {lab=DAC+}
N 460 -1060 470 -1060 {lab=VSS}
N 630 -1060 640 -1060 {lab=VSS}
N 390 -890 390 -880 {lab=VSS}
N 710 -890 710 -880 {lab=VSS}
N 390 -520 390 -510 {lab=VSS}
N 710 -520 710 -510 {lab=VSS}
N 460 -340 470 -340 {lab=VSS}
N 630 -340 640 -340 {lab=VSS}
N 780 -890 980 -890 {lab=Vm}
N 780 -510 1000 -510 {lab=Vp}
N 790 -890 790 -720 {lab=Vm}
N 790 -720 950 -720 {lab=Vm}
N 790 -680 790 -510 {lab=Vp}
N 790 -680 950 -680 {lab=Vp}
N 950 -685 950 -680 {lab=Vp}
N 1040 -890 1110 -890 {lab=Vop}
N 1060 -510 1120 -510 {lab=Vom}
N 1052.5 -693.75 1120 -693.75 {lab=Vom}
N 1051.25 -717.5 1118.75 -717.5 {lab=Vop}
N 1110 -890 1120 -890 {lab=Vop}
N 1118.75 -717.5 1120 -717.5 {lab=Vop}
N 1120 -717.5 1270 -717.5 {lab=Vop}
N 1120 -693.75 1270 -693.75 {lab=Vom}
N 1120 -890 1120 -717.5 {lab=Vop}
N 1120 -693.75 1120 -510 {lab=Vom}
N 1022.5 -687.5 1030 -687.5 {lab=Vbiasp}
N 1030 -687.5 1030 -640 {lab=Vbiasp}
N 990 -667.5 990 -640 {lab=Vbiasn}
C {opin.sym} 1340 -740 3 0 {name=p11 lab=Vop}
C {opin.sym} 1340 -680 3 1 {name=p12 lab=Vom}
C {iopin.sym} 1680 -550 0 0 {name=p21 lab=VDD}
C {iopin.sym} 1680 -470 0 0 {name=p22 lab=VSS}
C {lab_pin.sym} 1420 -740 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1420 -660 0 0 {name=p26 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1680 -930 2 0 {name=p27 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1680 -850 2 0 {name=p28 sig_type=std_logic lab=VSS}
C {ipin.sym} 1680 -530 2 0 {name=p29 lab=Vref+}
C {ipin.sym} 1680 -490 2 0 {name=p30 lab=Vref-}
C {opin.sym} 1780 -700 0 0 {name=p31 lab=Vout}
C {lab_pin.sym} 1680 -910 2 0 {name=p32 sig_type=std_logic lab=Vref+}
C {lab_pin.sym} 1680 -870 2 0 {name=p33 sig_type=std_logic lab=Vref-}
C {lab_pin.sym} 1420 -890 0 0 {name=p34 sig_type=std_logic lab=DAC-}
C {lab_pin.sym} 1420 -510 0 0 {name=p35 sig_type=std_logic lab=DAC+}
C {ipin.sym} 1420 -680 2 1 {name=p40 lab=clk2B}
C {A52/integrasi2/latched comparator/COMPARATOR_SD.sym} 1400 -540 0 0 {name=x2}
C {A52/integrasi2/DAC 1 BIT/DAC_1_BIT.sym} 1690 -950 2 0 {name=x3}
C {A52/integrasi2/DAC 1 BIT/DAC_1_BIT.sym} 1690 -570 2 0 {name=x4}
C {vsource.sym} -660 -610 0 0 {name=V10 value="PULSE(3.3 0 40.69n 1n 1n 36.69n 81.38n)" savecurrent=false}
C {gnd.sym} -660 -560 0 0 {name=l2 lab=0}
C {lab_pin.sym} -660 -680 1 0 {name=p52 sig_type=std_logic lab=clk2B}
C {vsource.sym} -880 -1140 0 0 {name=V1 value=3.3 savecurrent=false}
C {gnd.sym} -880 -1090 0 0 {name=l5 lab=0}
C {vsource.sym} -660 -1140 0 0 {name=V2 value=0 savecurrent=false}
C {gnd.sym} -660 -1090 0 0 {name=l6 lab=0}
C {vsource.sym} -440 -1140 0 0 {name=V3 value=0.65 savecurrent=false}
C {gnd.sym} -440 -1090 0 0 {name=l7 lab=0}
C {vsource.sym} -180 -1140 0 0 {name=V4 value=2.5 savecurrent=false}
C {gnd.sym} -180 -1090 0 0 {name=l8 lab=0}
C {vsource.sym} -880 -860 0 0 {name=V5 value="SIN(1.65 0.125 2k 0 0 0)" savecurrent=false}
C {gnd.sym} -880 -810 0 0 {name=l9 lab=0}
C {vsource.sym} -660 -860 0 0 {name=V6 value="SIN(1.65 0.125 2k 0 0 180)" savecurrent=false}
C {gnd.sym} -660 -810 0 0 {name=l10 lab=0}
C {vsource.sym} -440 -860 0 0 {name=V7 value="PULSE(0 3.3 0 1n 1n 36.69n 81.38n)" savecurrent=false}
C {gnd.sym} -440 -810 0 0 {name=l11 lab=0}
C {vsource.sym} -180 -860 0 0 {name=V8 value="PULSE(0 3.3 40.69n 1n 1n 36.69n 81.38n)" savecurrent=false}
C {gnd.sym} -180 -810 0 0 {name=l12 lab=0}
C {lab_pin.sym} -880 -1210 1 0 {name=p43 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -660 -1210 1 0 {name=p44 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} -440 -1210 1 0 {name=p45 sig_type=std_logic lab=Vbiasn
}
C {lab_pin.sym} -180 -1210 1 0 {name=p46 sig_type=std_logic lab=Vbiasp
}
C {lab_pin.sym} -880 -930 1 0 {name=p47 sig_type=std_logic lab=Vin+}
C {lab_pin.sym} -660 -930 1 0 {name=p48 sig_type=std_logic lab=Vin-}
C {lab_pin.sym} -440 -930 1 0 {name=p49 sig_type=std_logic lab=clk1}
C {lab_pin.sym} -180 -930 1 0 {name=p50 sig_type=std_logic lab=clk2}
C {vsource.sym} -880 -610 0 0 {name=V9 value=1.65 savecurrent=false}
C {gnd.sym} -880 -560 0 0 {name=l1 lab=0}
C {lab_pin.sym} -880 -680 1 0 {name=p51 sig_type=std_logic lab=VCM}
C {vsource.sym} -440 -610 0 0 {name=V11 value=3.3 savecurrent=false}
C {gnd.sym} -440 -560 0 0 {name=l3 lab=0}
C {lab_pin.sym} -440 -680 1 0 {name=p53 sig_type=std_logic lab=Vref-}
C {vsource.sym} -180 -610 0 0 {name=V12 value=0 savecurrent=false}
C {gnd.sym} -180 -560 0 0 {name=l4 lab=0}
C {lab_pin.sym} -180 -680 1 0 {name=p54 sig_type=std_logic lab=Vref+}
C {devices/code_shown.sym} 2021.25 -1073.75 0 0 {name=NGSPICE only_toplevel=true
value="
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice typical
.inc /foss/pdks/gf180mcuD/libs.tech/ngspice/design.ngspice

.param CL=0.5p
.param Wp=12u
.param Wn=6u
.param Kall=1.28u
.param Wpc=50u Wnc=2u Ws=2*Wp Ls=10u
CLP Vop 0 \{CL\}
CLM Vom 0 \{CL\}
RLEAKP Vop 0 1T
RLEAKM Vom 0 1T

* dummy load supaya tiap node punya DC path ke ground
Rd1 clk1  0 1meg
Rd2 clk2  0 1meg

.control
set color0=white
set color1=black
tran 1u 2m
let vicm_ota = (v(Vp)+v(Vm))/2
let vid_ota  = v(Vp)-v(Vm)
* --- window ala paper ---
*plot v(clk1) v(clk2) v(clk2B)         $ window 1: non-overlapping clocks
*plot v(Vin+) v(Vin-)          $ window 2: input diferensial
*plot v(Vop) v(Vom)            $ window 3: output OTA (single-ended)
*plot v(Vop)-v(Vom)            $ window 4: output integrator (diferensial) -> segitiga
*plot v(Vp) v(Vm)
*plot vicm_ota
*plot vid_ota
plot v(Vout) v(Vin+) v(Vin-)
.endc
.end
"}
C {symbols/nfet_03v3.sym} 440 -1060 2 1 {name=M1
L=0.3u
W=7.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 660 -1060 2 0 {name=M2
L=0.3u
W=7.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 390 -910 3 1 {name=M3
L=0.3u
W=7.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 710 -910 3 1 {name=M4
L=0.3u
W=7.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {capa.sym} 570 -890 1 1 {name=C1
m=1
value=50f
footprint=1206
device="ceramic capacitor"}
C {ipin.sym} 310 -890 0 0 {name=p3 lab=Vin+}
C {lab_pin.sym} 740 -1060 2 0 {name=p1 sig_type=std_logic lab=clk1}
C {lab_pin.sym} 740 -950 2 0 {name=p5 sig_type=std_logic lab=clk2}
C {symbols/nfet_03v3.sym} 440 -340 0 0 {name=M5
L=0.3u
W=7.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 660 -340 0 1 {name=M6
L=0.3u
W=7.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 390 -490 3 0 {name=M7
L=0.3u
W=7.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 710 -490 3 0 {name=M8
L=0.3u
W=7.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {capa.sym} 570 -510 1 0 {name=C3
m=1
value=50f
footprint=1206
device="ceramic capacitor"}
C {ipin.sym} 310 -510 2 1 {name=p6 lab=Vin-}
C {lab_pin.sym} 740 -340 0 1 {name=p7 sig_type=std_logic lab=clk1}
C {lab_pin.sym} 360 -450 2 1 {name=p8 sig_type=std_logic lab=clk1}
C {lab_pin.sym} 360 -340 2 1 {name=p9 sig_type=std_logic lab=clk2}
C {lab_pin.sym} 740 -450 0 1 {name=p10 sig_type=std_logic lab=clk2}
C {lab_pin.sym} 470 -1060 2 0 {name=p13 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 630 -1060 0 0 {name=p14 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 390 -880 3 0 {name=p15 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 710 -880 3 0 {name=p16 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 390 -520 1 0 {name=p17 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 710 -520 1 0 {name=p18 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 470 -340 2 0 {name=p19 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 630 -340 0 0 {name=p20 sig_type=std_logic lab=VSS}
C {capa.sym} 1010 -890 3 0 {name=C5
m=1
value=300f
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 1030 -510 3 0 {name=C6
m=1
value=300f
footprint=1206
device="ceramic capacitor"}
C {lab_pin.sym} 950 -665 0 0 {name=p23 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 950 -740 0 0 {name=p24 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 640 -280 3 0 {name=p38 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 640 -1120 1 0 {name=p39 sig_type=std_logic lab=VSS}
C {ipin.sym} 390 -930 3 1 {name=p41 lab=clk1}
C {ipin.sym} 420 -1060 2 1 {name=p2 lab=clk2}
C {ipin.sym} 990 -640 1 1 {name=p4 lab=Vbiasn}
C {ipin.sym} 1030 -640 1 1 {name=p42 lab=Vbiasp}
C {lab_pin.sym} 860 -720 1 0 {name=p36 sig_type=std_logic lab=Vm}
C {lab_pin.sym} 860 -680 3 0 {name=p37 sig_type=std_logic lab=Vp}
C {lab_pin.sym} 460 -1120 1 0 {name=p55 sig_type=std_logic lab=DAC-}
C {lab_pin.sym} 460 -280 3 0 {name=p56 sig_type=std_logic lab=DAC+}
C {A52/integrasi2/FULLY DIFFERENTIAL AMPLIFIER/fullydiffamp.sym} 1010 -615 0 0 {name=x1}
